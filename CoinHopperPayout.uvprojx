# Keil uVision project CoinHopperPayout.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CoinHopperPayout
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart;.\user;.\SYSTEM\timer;.\Cmd;.\SYSTEM\spi
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Objects\CounterEmitter.sct
  link misc: --keep=my_cmd.o(my_cmd_sec)
  group user
    ./user/: main.c led.c
    ./my_printf/: retarget.c
  group system
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart1.c usart2.c usart3.c usart4.c usart1.h usart2.h usart3.h usart4.h usart5.h usart5.c
    ./SYSTEM/spi/: spi.c spi.h
  group cmd
    ./Cmd/: my_cmd.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
